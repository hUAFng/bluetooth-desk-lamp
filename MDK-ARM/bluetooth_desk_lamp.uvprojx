# Keil uVision project bluetooth_desk_lamp.uvprojx, settings and files
target bluetooth_desk_lamp (5060183::V5.06 update 2 (build 183)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bluetooth_desk_lamp +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../BSP;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/Applayer;../BSP/Driverlayer;../BSP/Modulelayer/Asrpro;../BSP/Modulelayer/BlueTooth;../BSP/Modulelayer/Light_Sensor;../BSP/Modulelayer/MIC;../BSP/Modulelayer/Module;../BSP/Modulelayer/RGB;../BSP/Modulelayer/TFT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Applayer
    ../BSP/Applayer/: app_algorithm.c app_algorithm.h app_common.c app_common.h app_manager.c app_manager.h app_modes.c app_modes.h app_ui.c app_ui.h
  group Modulelayer
    ../BSP/Modulelayer/Asrpro/: asrpro_drv.c asrpro_drv.h
    ../BSP/Modulelayer/BlueTooth/: BT_drv.c BT_drv.h
    ../BSP/Modulelayer/MIC/: mic_drv.c mic_drv.h
    ../BSP/Modulelayer/Module/: module_layer.c module_layer.h
    ../BSP/Modulelayer/RGB/: DWT.c DWT.h rgb_drv.c rgb_drv.h
    ../BSP/Modulelayer/TFT/: tft_drv.c tft_drv.h tft_fonts.c tft_fonts.h
    ../BSP/Modulelayer/Light_Sensor/: light_sensor_drv_i2c.c light_sensor_drv_i2c.h
  group Driverlayer
    ../BSP/Driverlayer/: key.c key.h led.c led.h i2c_drv.c i2c_drv.h adc_drv.c adc_drv.h buzzer_drv.c buzzer_drv.h drv_layer.c drv_layer.h spi_drv.c spi_drv.h uart_drv.c uart_drv.h cmd.c cmd.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 6.2.0
